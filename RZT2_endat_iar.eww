<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RZT2_endat_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>
